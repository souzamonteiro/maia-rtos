#include <maia/soc/esp32p4_regs.h>
#include <stdio.h>

int main(void) {
    /* Positive contract checks against esp-idf/components/soc/esp32p4/register/soc/ headers */
    if (MAIA_ESP32P4_L2MEM_LOW != 0x4FF00000UL) return 1;
    if (MAIA_ESP32P4_L2MEM_ROM_BUF_LOW != 0x4FF296B8UL) return 2;
    if (MAIA_ESP32P4_L2MEM_ROM_RSV_HIGH != 0x4FF40000UL) return 3;
    if (MAIA_ESP32P4_L2MEM_HIGH != 0x4FFC0000UL) return 4;

    if (MAIA_ESP32P4_TIMG0_BASE != 0x500C2000UL) return 5;
    if (MAIA_ESP32P4_TIMG1_BASE != 0x500C3000UL) return 6;
    if (MAIA_ESP32P4_UART0_BASE != 0x500CA000UL) return 7;
    if (MAIA_ESP32P4_USB_SERIAL_JTAG_BASE != 0x500D2000UL) return 8;
    if (MAIA_ESP32P4_LP_WDT_BASE != 0x50116000UL) return 9;
    if (MAIA_ESP32P4_WDT_WKEY_VALUE != 0x50D83AA1UL) return 10;

    if (MAIA_ESP32P4_TIMG_WDTCONFIG0_REG(MAIA_ESP32P4_TIMG0_BASE) != 0x500C2048UL) return 11;
    if (MAIA_ESP32P4_TIMG_WDTWPROTECT_REG(MAIA_ESP32P4_TIMG0_BASE) != 0x500C2064UL) return 12;
    if (MAIA_ESP32P4_LP_WDT_CONFIG0_REG != 0x50116000UL) return 13;
    if (MAIA_ESP32P4_LP_WDT_WPROTECT_REG != 0x50116018UL) return 14;
    if (MAIA_ESP32P4_LP_WDT_SWD_CONFIG_REG != 0x5011601CUL) return 15;
    if (MAIA_ESP32P4_LP_WDT_SWD_WPROTECT_REG != 0x50116020UL) return 16;

    if (MAIA_ESP32P4_USB_EP1_REG != 0x500D2000UL) return 17;
    if (MAIA_ESP32P4_USB_EP1_CONF_REG != 0x500D2004UL) return 18;
    if (MAIA_ESP32P4_UART0_FIFO_REG != 0x500CA000UL) return 19;
    if (MAIA_ESP32P4_UART0_STATUS_REG != 0x500CA01CUL) return 20;

    /* Vendor peripheral map: +0x22000; +0x6000 belongs to I2S0. */
    if (MAIA_ESP32P4_SYSTIMER_BASE == 0x500C6000UL) return 46;
    if (MAIA_ESP32P4_SYSTIMER_BASE != 0x500E2000UL) return 21;
    if (MAIA_ESP32P4_SYSTIMER_UNIT0_OP_REG != 0x500E2004UL) return 22;
    if (MAIA_ESP32P4_SYSTIMER_TARGET0_CONF_REG != 0x500E2034UL) return 23;
    if (MAIA_ESP32P4_SYSTIMER_UNIT0_VAL_HI_REG != 0x500E2040UL) return 24;
    if (MAIA_ESP32P4_SYSTIMER_UNIT0_VAL_LO_REG != 0x500E2044UL) return 25;
    if (MAIA_ESP32P4_SYSTIMER_COMP0_LOAD_REG != 0x500E2050UL) return 26;
    if (MAIA_ESP32P4_SYSTIMER_INT_ENA_REG != 0x500E2064UL) return 27;
    if (MAIA_ESP32P4_SYSTIMER_INT_CLR_REG != 0x500E206CUL) return 28;
    if (MAIA_ESP32P4_INTR_CORE0_SYSTIMER0_MAP != 0x500D60D4UL) return 29;
    if (MAIA_ESP32P4_INTR_SRC_SYSTIMER_TARGET0 != 53UL) return 44;
    /* Reject the previous off-by-one route to the target-1 register. */
    if (MAIA_ESP32P4_INTR_CORE0_SYSTIMER0_MAP == MAIA_ESP32P4_INTR_CORE0_MAP_REG(54UL)) return 45;
    if (MAIA_ESP32P4_CLIC_INT_CONFIG_REG != 0x20800000UL) return 30;
    if (MAIA_ESP32P4_CLIC_INT_THRESH_REG != 0x20800008UL) return 31;
    if (MAIA_ESP32P4_CLIC_INT_CTRL_REG(16UL) != 0x20801040UL) return 32;

    if (MAIA_ESP32P4_LEDC_BASE != 0x500D3000UL) return 33;
    if (MAIA_ESP32P4_LEDC_CH0_CONF0_REG != 0x500D3000UL) return 34;
    if (MAIA_ESP32P4_LEDC_CH0_DUTY_REG != 0x500D3008UL) return 35;
    if (MAIA_ESP32P4_LEDC_CH1_CONF0_REG != 0x500D3014UL) return 36;
    if (MAIA_ESP32P4_LEDC_CH1_DUTY_REG != 0x500D301CUL) return 37;
    if (MAIA_ESP32P4_LEDC_TIMER0_CONF_REG != 0x500D30A0UL) return 38;
    if (MAIA_ESP32P4_LEDC_CONF_REG != 0x500D3170UL) return 39;
    if (MAIA_ESP32P4_SIG_LEDC_LS_OUT0_IDX != 126UL) return 40;
    if (MAIA_ESP32P4_SIG_LEDC_LS_OUT1_IDX != 127UL) return 41;
    if (MAIA_ESP32P4_HP_CLKRST_SOC_CLK_CTRL3_REG != 0x500E6020UL) return 42;
    if (MAIA_ESP32P4_HP_CLKRST_HP_RST_EN1_REG != 0x500E60C4UL) return 43;

    if (MAIA_ESP32P4_GPIO_FUNC_OUT_SEL_REG(31U) != 0x500E05D4UL) return 47;
    if (MAIA_ESP32P4_GPIO_FUNC_OUT_SEL_REG(32U) != 0x500E05D8UL) return 48;
    if (MAIA_ESP32P4_GPIO_FUNC_OEN_SEL != (1UL << 10U)) return 49;
    if (MAIA_ESP32P4_EFUSE_MAC_SYS2_REG != 0x5012D04CUL) return 50;
    if (MAIA_ESP32P4_EFUSE_MAC_SYS3_REG != 0x5012D050UL) return 51;
    if (MAIA_ESP32P4_EFUSE_RS_ERR0_REG != 0x5012D1C0UL) return 52;
    if (MAIA_ESP32P4_HP_MIPI_SYS_CLK_REG != 0x500E6018UL || MAIA_ESP32P4_HP_MIPI_SYS_CLK_MASK != 0x1C00UL) return 53;
    if (MAIA_ESP32P4_HP_MIPI_PHY_CLK_REG != 0x500E603CUL || MAIA_ESP32P4_HP_MIPI_PHY_CLK_MASK != 0x93UL) return 54;
    if (MAIA_ESP32P4_LDO3_CONTROL_MASK != 0x4F80UL || MAIA_ESP32P4_LDO3_ANALOG_MASK != 0xF7800000UL) return 55;
    puts("ESP32-P4 register address contract PASS");
    return 0;
}
